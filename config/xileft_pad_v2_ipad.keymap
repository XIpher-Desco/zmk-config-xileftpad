/*
 * SPDX-License-Identifier: MIT
 *
 * xileft pad v2 の iPad 版キーマップ。
 * v1 iPad 版とキーマップは完全共通なので include で一元管理する。
 * v2 だけ変えたくなったら、この include をやめて中身を直接書くこと。
 */

#include "xileft_pad_ipad.keymap"
